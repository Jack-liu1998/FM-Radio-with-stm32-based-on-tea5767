# Keil uVision project 语音模块.uvprojx, settings and files
target 语音模块 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 语音模块 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\CORE;.\HARDWARE\LCD;.\HARDWARE\LED;.\HARDWARE\LXD5516;.\HARDWARE\TIMER;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\HARDWARE\BUS;.\HARDWARE\VOICE;.\HARDWARE\SPI;.\HARDWARE;.\HARDWARE\LCD;.\HARDWARE\SPI;.\HARDWARE\Touch;.\SYSTEM\fm;.\HARDWARE\saveFlash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
    ./HARDWARE/: myiic.c TEA5767.c
  group HARDWARE
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/SPI/: bsp_spi.c spi.c
    ./HARDWARE/LCD/: GUI.c hz16.c ILI93xx.c
    ./HARDWARE/Touch/: Touch.c
    ./HARDWARE/saveFlash/: save_Flash.c
  group FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/fm/: fm.c
  group READ
    ./USER/: read.txt
